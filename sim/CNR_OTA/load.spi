*Load network

IDC 0 IBPSR dc 2u

R1 VSIP VIP 100k
R2 VSIN VIN 100k
R3 LOP VIN 500k
R4 LON VIP 500k

CL1 VOP 0 5p
CL2 VON 0 5p
